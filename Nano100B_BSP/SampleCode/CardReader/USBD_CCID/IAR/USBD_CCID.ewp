# IAR project USBD_CCID.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100BN series Nuvoton Nano100BN series (Nano100BN,Nano110BN,Nano120BN,Nano130BN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\SmartcardLib\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_CCID.bin
  ILINK.IlinkOutputFile: USBD_CCID.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sc.c sys.c uart.c usbd.c
    ../../../../Library/SmartcardLib/: SmartCardLib_IAR.a
  group User
    ../: ccid.c Ccid_if.c descriptors.c main.c sc_intf.c
