# IAR project PWRDWN_LCD_RTC_DEMO.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100BN series Nuvoton Nano100BN series (Nano100BN,Nano110BN,Nano120BN,Nano130BN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\LCDLib\Include; ..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include; ..\..\..\..\Library\StdDriver\Inc; ..\..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: PWRDWN_LCD_RTC_DEMO.bin
  ILINK.IlinkOutputFile: PWRDWN_LCD_RTC_DEMO.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Libraries
    ../../../../Library/StdDriver/src/: clk.c lcd.c retarget.c rtc.c sys.c uart.c
    ../../../../Library/LCDLib/Source/: LCDLIB.c
  group User
    ../../COMMON/: LCD_Commom.c LCDLIB_Panel.c RTC_Common.c
    ../: main.c
