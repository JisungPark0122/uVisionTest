# IAR project fmc_ap_main.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100BN series Nuvoton Nano100BN series (Nano100BN,Nano110BN,Nano120BN,Nano130BN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include; $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fmc_ap_main.bin
  ILINK.IlinkOutputFile: fmc_ap_main.out
  ILINK.IlinkExtraOptions: --image_input Release\Exe\fmc_ld_boot.bin,loaderImage1Base,.bin_image,4; --image_input Release\Exe\fmc_isp.bin,loaderImage2Base,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group Source Files
    ../: ap_main.c
