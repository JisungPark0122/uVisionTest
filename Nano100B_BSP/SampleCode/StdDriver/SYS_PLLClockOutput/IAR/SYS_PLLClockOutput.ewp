# IAR project SYS_PLLClockOutput.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100BN series Nuvoton Nano100BN series (Nano100BN,Nano110BN,Nano120BN,Nano130BN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\library\Device\Nuvoton\Nano100Series\Include; $PROJ_DIR$..\..\..\..\..\library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_PLLClockOutput.bin
  ILINK.IlinkOutputFile: SYS_PLLClockOutput.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group Source Files
    ../: main.c
