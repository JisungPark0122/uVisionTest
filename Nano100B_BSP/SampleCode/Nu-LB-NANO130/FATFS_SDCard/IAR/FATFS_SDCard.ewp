# IAR project FATFS_SDCard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100BN series Nuvoton Nano100BN series (Nano100BN,Nano110BN,Nano120BN,Nano130BN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc; $PROJ_DIR$..\..\FF8\src; $PROJ_DIR$..\..\..\..\..\Library\SDCardLib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FATFS_SDCard.bin
  ILINK.IlinkOutputFile: FATFS_SDCard.out
  ILINK.IlinkIcfFile: FATFS_SDCard.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Libraries
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c sys.c uart.c
    ../../../../Library/SDCardLib/: SDCard.c
  group User
    ../FF8/src/option/: ccsbcs.c
    ../FF8/src/: diskio.c ff.c
    ../: FATFS_SDCard.c
