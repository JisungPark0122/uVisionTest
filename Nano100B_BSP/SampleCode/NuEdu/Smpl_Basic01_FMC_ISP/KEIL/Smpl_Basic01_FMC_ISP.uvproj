# Keil uVision project Smpl_Basic01_FMC_ISP.uvproj, settings and files
target FMC_ISP (ARM-ADS)
  device: NANO110RE3BN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_ISP
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1
  c define: DEBUG_PORT=UART1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\NuEdu\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group Libraries
    ../../../../Library/StdDriver/src/: pwm.c clk.c sys.c uart.c gpio.c fmc.c
  group Common
    ../../../../Library/StdDriver/src/: retarget.c
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group User
    ../: main.c LoaderImage.s
  group NuEdu
    ../../../../Library/NuEdu/src/: NuEdu-Basic01_LED.c
